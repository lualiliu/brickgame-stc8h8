# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c display.c tetris.c voice.c core.h rom.h sys.h display.h voice.h stc8h.h stc8g.h
